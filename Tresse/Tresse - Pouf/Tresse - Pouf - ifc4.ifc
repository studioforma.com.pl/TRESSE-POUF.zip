Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Tresse - Pouf - ifc4.ifc
Time: 2023-10-09T11:01:29
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (11)
Name
 | 1_9 - ObjectType: SketchupGroup
 | 1_8 - ObjectType: SketchupGroup
 | 1_1 - ObjectType: SketchupGroup
 | 1_3 - ObjectType: SketchupGroup
 | 1_4 - ObjectType: SketchupGroup
 | 1_2 - ObjectType: SketchupGroup
 | 1_0 - ObjectType: SketchupGroup
 | 1_10 - ObjectType: SketchupGroup
 | 1_5 - ObjectType: SketchupGroup
 | 1_6 - ObjectType: SketchupGroup
 | 1_7 - ObjectType: SketchupGroup
